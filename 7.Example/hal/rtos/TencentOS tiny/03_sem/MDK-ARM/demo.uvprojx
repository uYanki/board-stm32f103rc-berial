# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../ARM_pack/Target;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Kernel/core/include;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Kernel/hal/include;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Arch/arm/arm-v7m/common/include;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Arch/arm/arm-v7m/cortex-m3/armcc;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Cmsis_os;C:/Users/Administrator/STM32Cube/Repository/Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Example;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: apps.c main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Middlewares/ARM_pack/TencentOS tiny/Kernel/core
    C:/Users/Administrator/STM32Cube/Repository//Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group Middlewares/ARM_pack/TencentOS tiny/Arch/Cortex_M3/armcc
    C:/Users/Administrator/STM32Cube/Repository//Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Arch/arm/arm-v7m/cortex-m3/armcc/: port_s.S port_c.c
    C:/Users/Administrator/STM32Cube/Repository//Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group Middlewares/ARM_pack/TencentOS tiny/Cmsis_os/cmsis_os
    C:/Users/Administrator/STM32Cube/Repository//Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Cmsis_os/: cmsis_os.c
  group Middlewares/ARM_pack/TencentOS tiny/Example/mcu_it
    C:/Users/Administrator/STM32Cube/Repository//Packs/Tencent/TencentOS-tiny/1.0.0/Middlewares/Third_Party/Example/: mcu_it.c
software components: CMSIS:CORE 5.5.0
