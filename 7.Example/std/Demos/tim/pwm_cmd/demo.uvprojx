# Keil uVision project demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x\;..\..\..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\..\..\Drivers\CMSIS\CM3\CoreSupport;.\Core\Inc;..\Lib;..\..\..\Board\Inc;..\..\uart\nr_micro_shell\Lib\nr_micro_shell\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Drivers/Startup
    ./Core/Src/: startup_stm32f10x_hd.s
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
    ../../../Drivers/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Drivers/FWLib
    ../../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Application/User
    ./Core/Src/: stm32f10x_it.c main.c
  group Application/Board
    ./Core/Inc/: board_conf.h
    ../../../Board/Src/: board.c debug.c delay.c pinctrl.c
  group Libraries/Shell
    ../../uart/nr_micro_shell/Lib/nr_micro_shell/src/: ansi.c ansi_port.c nr_micro_shell.c nr_micro_shell_commands.c
  group Docs
    ./: README.md
