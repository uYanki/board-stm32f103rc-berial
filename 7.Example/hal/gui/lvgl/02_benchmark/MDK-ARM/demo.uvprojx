# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include;../Lib;../Lib/lvgl;../../Lib;../../Lib/lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group lvgl/core
    ../../Lib/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/draw
    ../../Lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Lib/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c
    ../../Lib/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c
    ../../Lib/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Lib/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/hal
    ../../Lib/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/layout
    ../../Lib/lvgl/src/layouts/flex/: lv_flex.c
    ../../Lib/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/widgets
    ../../Lib/lvgl/src/widgets/animimg/: lv_animimg.c
    ../../Lib/lvgl/src/widgets/arc/: lv_arc.c
    ../../Lib/lvgl/src/widgets/bar/: lv_bar.c
    ../../Lib/lvgl/src/widgets/btn/: lv_btn.c
    ../../Lib/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../../Lib/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Lib/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Lib/lvgl/src/widgets/chart/: lv_chart.c
    ../../Lib/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Lib/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../../Lib/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Lib/lvgl/src/widgets/img/: lv_img.c
    ../../Lib/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../../Lib/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Lib/lvgl/src/widgets/label/: lv_label.c
    ../../Lib/lvgl/src/widgets/led/: lv_led.c
    ../../Lib/lvgl/src/widgets/line/: lv_line.c
    ../../Lib/lvgl/src/widgets/list/: lv_list.c
    ../../Lib/lvgl/src/widgets/menu/: lv_menu.c
    ../../Lib/lvgl/src/widgets/meter/: lv_meter.c
    ../../Lib/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Lib/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Lib/lvgl/src/widgets/roller/: lv_roller.c
    ../../Lib/lvgl/src/widgets/slider/: lv_slider.c
    ../../Lib/lvgl/src/widgets/span/: lv_span.c
    ../../Lib/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Lib/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Lib/lvgl/src/widgets/switch/: lv_switch.c
    ../../Lib/lvgl/src/widgets/table/: lv_table.c
    ../../Lib/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Lib/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Lib/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Lib/lvgl/src/widgets/win/: lv_win.c
  group lvgl/misc
    ../../Lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/other
    ../../Lib/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Lib/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Lib/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Lib/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Lib/lvgl/src/others/monkey/: lv_monkey.c
    ../../Lib/lvgl/src/others/msg/: lv_msg.c
  group lvgl/theme
    ../../Lib/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../Lib/lvgl/src/themes/basic/: lv_theme_basic.c
    ../../Lib/lvgl/src/themes/default/: lv_theme_default.c
    ../../Lib/lvgl/src/themes/mono/: lv_theme_mono.c
  group lvgl/port
    ../Lib/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../Lib/lvgl/: lv_conf.h
  group lvgl/font
    ../../Lib/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lib/st7735
    ../../Lib/st7735/: st7735.c
  group lvgl/example
    ../Lib/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Lib/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
software components: CMSIS:CORE 5.5.0
